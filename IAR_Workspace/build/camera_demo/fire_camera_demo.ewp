# IAR project fire_camera_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: IAR; DEBUG; TWR_K60N512; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\src\LIB\CMSIS; ..\..\src\LIB\FatFs; ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\adc; ..\..\src\drivers\AT24C02; ..\..\src\drivers\port; ..\..\src\drivers\delay; ..\..\src\drivers\dma; ..\..\src\drivers\FTM; ..\..\src\drivers\PWM; ..\..\src\drivers\gpio; ..\..\src\drivers\i2c; ..\..\src\drivers\LCD; ..\..\src\drivers\LED; ..\..\src\drivers\IMG; ..\..\src\drivers\lptmr; ..\..\src\drivers\key; ..\..\src\drivers\NRF24L0; ..\..\src\drivers\ov7725; ..\..\src\drivers\spi; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\sdhc; ..\..\src\drivers\rtc; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\src\drivers\camera; ..\..\src\projects\fire_camera_demo; ..\..\build; ..\..\src\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fire_gpio_demo.hex
  ILINK.IlinkOutputFile: fire_gpio_demo.out
  ILINK.IlinkIcfFile: ..\config files\fire_ROM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; IAR; TWR_K60N512; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\src\LIB\CMSIS; ..\..\src\LIB\FatFs; ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\adc; ..\..\src\drivers\AT24C02; ..\..\src\drivers\port; ..\..\src\drivers\delay; ..\..\src\drivers\dma; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\i2c; ..\..\src\drivers\LCD; ..\..\src\drivers\LED; ..\..\src\drivers\lptmr; ..\..\src\drivers\key; ..\..\src\drivers\NRF24L0; ..\..\src\drivers\ov7725; ..\..\src\drivers\spi; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\sdhc; ..\..\src\drivers\rtc; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\src\drivers\camera; ..\..\src\projects\fire_camera_demo; ..\..\build
  ICCARM.CCOptLevel: 3
  group app
    ../../src/projects/fire_camera_demo/: isr.c main.c
  group buildLib
    ../../src/drivers/camera/: CAMERA_FUNC.c
    ../../src/drivers/IMG/: IMG_FUNC.c
    ../../src/projects/fire_camera_demo/: init.c
    ../../src/drivers/lcd/: MENU.c
    ../../src/drivers/PWM/: MOTOR.c STEERING_GEAR.c
  group common
    ../../src/common/: alloc.c assert.c io.c memtest.c printf.c queue.c startup.c stdlib.c uif.c
  group cpu
    ../../src/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group drivers
    ../../src/drivers/lcd/: ASCII.c BL144002.c LCD.c LCD_CH.c
    ../../src/drivers/uart/: COMMUNICATION.c uart.c
    ../../src/drivers/delay/: delay.c
    ../../src/drivers/dma/: dma.c
    ../../src/drivers/FTM/: FTM.c
    ../../src/drivers/gpio/: gpio.c
    ../../src/drivers/LED/: LED.C
    ../../src/drivers/lptmr/: lptmr.c
    ../../src/drivers/mcg/: mcg.c
    ../../src/drivers/camera/: OV7725.c SCCB.c
    ../../src/drivers/PIT/: PIT.c
    ../../src/drivers/port/: port.c
    ../../src/drivers/sdhc/: sdhc.c
    ../../src/drivers/spi/: spi.c
    ../../src/drivers/wdog/: wdog.c
  group header
    ../../src/common/: common.h
    ../../src/projects/fire_sd_demo/: include.h isr.h
    ../../src/platforms/: k60_fire.h
  group lib/CMSIS
    ../../src/LIB/CMSIS/: iar_cortexM4l_math.a
  group lib/FatFs
    ../../src/LIB/FatFs/: diskio.c ff.c
